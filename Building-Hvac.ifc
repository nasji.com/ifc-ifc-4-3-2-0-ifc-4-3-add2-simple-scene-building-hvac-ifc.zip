Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [ReferenceView]
File name: Building-Hvac.ifc
Time: 2026-06-23T11:54:07
Written by: Sketchup-IFC-manager 5.6.0 / SketchUp 2026 (26.2.242)
Made in: BIM_Tools - Sketchup_IFC_manager - 5.6.0

# IfcProject, ifc silly sample scene - project
Description: Demystifying IFC with a playful scene using diverse building elements and compositions.

# IfcSite (2)
RefElevation: 0 mm
Name | Description
environment - site | A sample scene environment, showcasing the surrounding landscape.
house - site | Smoke curls from a friendly chimney, promising warmth within this idyllic hilltop house.

# IfcBuilding: house, Single-family house
Description: The main building structure, providing shelter and space.; ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm; Classification: E-AAA Single-family house (CCI Construction)

# IfcBuildingStorey: buildingstorey, 00 groundfloor
In: Single-family house
Description: The ground floor, forming the base level of the building.

# IfcAirTerminal: chimney cover
In: 00 groundfloor
Type - Description: A sturdy cover, protecting the chimney from the elements.; ElementType: chimney cover; PredefinedType: USERDEFINED
Material: metal_steel_generic_coated-anthracitegrey; Group: house - chimney flue

# IfcAirTerminal: house fireplace cap
In: 00 groundfloor
Type - Description: A hidden concrete cap, secretly keeping the fireplace safe and sound.; ElementType: fireplace cap; PredefinedType: USERDEFINED
Material: concrete_reinforced_prefab; Group: house - chimney flue

# IfcBuildingElementProxy: geo-reference
In: environment - site
Type - Description: The reference point for transforming the local engineering coordinate system into the coordinate reference system of the underlying map.; ElementType: origin; PredefinedType: USERDEFINED
Material: virtual_black

# IfcBuildingElementProxy: origin
In: house - site
Type - Description: The local position for coordination of aspect models.; ElementType: origin; PredefinedType: USERDEFINED
Material: virtual_white

# IfcChimney: house - chimney
In: 00 groundfloor
Type - Description: A chimney, standing tall and proud, guiding smoke away from the home.; ElementType: flue; PredefinedType: USERDEFINED
Material: stone_sand-lime

# IfcDistributionSystem: exhaust, house - chimney flue
Description: A vital passage, guiding smoke safely out of the home.; PredefinedType: EXHAUST

# IfcDuctSegment: building element
In: 00 groundfloor
Type - ElementType: rigidsegment; PredefinedType: RIGIDSEGMENT
Material: metal_steel-galvanized; Group: house - chimney flue
